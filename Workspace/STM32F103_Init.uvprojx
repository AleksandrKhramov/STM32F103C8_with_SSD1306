# Keil uVision project STM32F103_Init.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_Init +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Workspace;.\CMSIS\inc;.\Code\inc;.\FreeRTOS\inc;.\display;.\display\fonts;.\SSD1306\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Code
    ./Code/src/: main.c
    ./Code/inc/: FreeRTOSConfig.h
  group FreeRTOS
    ./FreeRTOS/src/: event_groups.c heap_1.c port.c queue.c tasks.c timers.c stream_buffer.c list.c croutine.c
  group Display
    ./display/: disp1color.c
    ./display/fonts/: f6x8m.c f10x16f.c font.c
  group SSD1306
    ./SSD1306/src/: SSD1306.c
